FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_imx7s-warp += "file://0001-change-Board-name.patch"
