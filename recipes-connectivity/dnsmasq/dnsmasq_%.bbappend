# Files directory
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

